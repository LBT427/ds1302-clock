# Keil uVision project 51.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\BSP\DS1302;..\BSP\IIC;..\BSP\LCD;..\BSP\Display;..\USER\timer
  group USER
    ./: STARTUP.A51
    ../USER/: main.c
    ../USER/timer/: timer.c
  group BSP
    ../BSP/DS1302/: ds1302.c
    ../BSP/IIC/: iic.c
    ../BSP/LCD/: lcd1602.c
